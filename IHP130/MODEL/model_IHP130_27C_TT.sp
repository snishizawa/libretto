.lib "../IHP130/libs.tech/ngspice/models/cornerMOSlv.lib" mos_tt

 .TEMP 27
