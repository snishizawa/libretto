.inc ../OSU350/MODEL/FF/nmos.sp
.inc ../OSU350/MODEL/FF/pmos.sp

* .TEMP 25
