.inc /home/synology_nfs/Techlibs/Techlib/OSU035/SS/nmos.sp
.inc /home/synology_nfs/Techlibs/Techlib/OSU035/SS/pmos.sp

* .TEMP -40
