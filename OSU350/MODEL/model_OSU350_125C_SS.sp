.inc ../OSU350/MODEL/SS/nmos.sp
.inc ../OSU350/MODEL/SS/pmos.sp

* .TEMP 25
