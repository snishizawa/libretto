.inc ../OSU350/MODEL/TT/nmos.sp
.inc ../OSU350/MODEL/TT/pmos.sp

* .TEMP 25
